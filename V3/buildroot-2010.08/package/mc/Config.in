## V3/buildroot-2010.08/package/mc/Config.in
```kconfig
config BR2_PACKAGE_MC
	bool "mc"
	help
            mc-mp file manager
            
            
```
